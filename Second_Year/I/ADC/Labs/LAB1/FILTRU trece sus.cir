[aimspice]
[description]
82
Filtru Trece-Sus
c1 in out 1800n
r1 out 0 1k
vin in 0 dc 5 sin(0 5 100 0 0)

[dc]
1
vin
0
5
0.1
[tran]
1e-9
6e-3
X
X
0
[ana]
4 1
0
1 1
1 1 0 5
2
v(in)
v(out)
[end]
